# Keil uVision project MotorDriver.uvproj, settings and files
target C8051F320 (MCS-51)
  device: C8051F320 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0x3FFF) CLOCK(25000000)
  output: MotorDriver +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: STARTUP.A51 Motor_Control.c USB_Descriptor.c USB_ISR.c USB_Main.c USB_ReportHandler.c USB_Standard_Requests.c
  group Headers
    ./: Motor_Control.h USB_Descriptor.h USB_ISR.h USB_Register.h USB_ReportHandler.h
